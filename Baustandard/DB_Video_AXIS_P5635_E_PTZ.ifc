Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: d3ba7735-4996-4f2e-a220-48985317c84a, VersionGUID: 44f114b8-652d-4e34-88d7-4fcb713364eb, NumberOfSaves: 366]
File name: DB_Video_AXIS_P5635_E_PTZ.ifc
Time: 2026-05-19T18:07:49+01:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.40.26 (DEU) - IFC 24.3.20.0

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 m
Pset_SiteCommon - Reference: Projektinformationen

# IfcBuilding
Pset_BuildingCommon - Reference: Projektinformationen; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Projektinformationen; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Projektinformationen; sets with these values: 2

# IfcBuildingStorey: Ebene:Ebene, DB_Bezugshoehe_max_Bahnsteigkante
LongName: DB_Bezugshoehe_max_Bahnsteigkante; Elevation: 0 m
Pset_BuildingStoreyCommon - Reference: Ebene

# IfcBuildingStorey: Ebene:Hilfsebene PU, Ebene 0
LongName: Ebene 0; Elevation: 0 m
Pset_BuildingStoreyCommon - Reference: Hilfsebene PU

# IfcBuildingElementProxy: DB_Ueberwachungskamera_Standard:DB_Ueberwachungskamera_Standard, DB_Ueberwachungskamera_Standard:DB_Ueberwachungskamera_Standard:6570
In: DB_Bezugshoehe_max_Bahnsteigkante
Type - Material: DB_Aluminium_RAL9006
Pset_BuildingElementProxyCommon - Reference: DB_Ueberwachungskamera_Standard; IsExternal: yes
Pset_EnvironmentalImpactIndicators - Reference: DB_Ueberwachungskamera_Standard
DB - DBAnlagentyp: Video; Objekt: DB Überwachungskamera Standard; Objektklasse: Ueberwachungskamera

# IfcBuildingElementProxy: DB_Video_AXIS_P5635_E_PTZ:DB_Video_AXIS_P5635_E_PTZ, DB_Video_AXIS_P5635_E_PTZ:DB_Video_AXIS_P5635_E_PTZ:6584
In: DB_Bezugshoehe_max_Bahnsteigkante
Type - Material: DB_Aluminium_RAL9006
Pset_BuildingElementProxyCommon - IsExternal: yes; Reference: DB_Video_AXIS_P5635_E_PTZ
Pset_EnvironmentalImpactIndicators - Reference: DB_Video_AXIS_P5635_E_PTZ
DB - DBAnlagentyp: Video; Objekt: DB Video AXIS P5635; Objektklasse: Ueberwachungskamera

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE
Name | SystemType
Port_6570_1 | ELECTRICAL
Port_6584_1 | SECURITY
